# Keil uVision project Blinking_LED_Control.uvprojx, settings and files
target Target 1 (6140001::V6.14.1::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Blinking_LED_Control
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\HAL;.\MCAL;.\Service;.\Application;.\MCAL\Includes
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./MCAL/: Gpio.c Gpt.c Interrupt.c SysTick.c Port.c
    ./MCAL/Includes/: Gpio.h Gpt.h Interrupt.h SysTick.h SysTick_Cfg.h SysTick_Types.h Port.h
  group Application
    ./Application/: main.c
  group Service
    ./Service/: Platform_Types.h TM4C_Registers.h Common_Macros.h Typedefs.h
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
